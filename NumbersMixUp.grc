options:
  parameters:
    author: murat
    generate_options: qt_gui
    id: NumbersMixUp
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: flag1
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-785.397e-3'
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: '785.397e-3'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: flag2
    type: float
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    comment: flag3
    type: float
  states: {}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    comment: flag4
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: Signal.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '5'
    type: float
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_complex_to_real_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_real_0_0, '0', blocks_sub_xx_0_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_rotator_cc_0, '0']
- [blocks_float_to_complex_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_rotator_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_complex_to_real_0_0, '0']
- [blocks_sub_xx_0, '0', qtgui_freq_sink_x_0, '2']
- [blocks_sub_xx_0_0, '0', qtgui_freq_sink_x_0, '3']
- [blocks_sub_xx_0_0_0, '0', audio_sink_0_0, '0']
- [blocks_sub_xx_0_0_0, '0', qtgui_freq_sink_x_0, '4']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '0', blocks_sub_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '1', blocks_add_xx_0, '1']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0, '1', blocks_sub_xx_0, '1']
- [blocks_wavfile_source_0, '1', blocks_sub_xx_0_0_0, '1']

metadata:
  file_format: 1
