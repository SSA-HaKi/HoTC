options:
  parameters:
    generate_options: qt_gui
    id: RTSA_Fosphor
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: samp_rate
    stop: 6000e6
    value: 2.4e9
  states: {}
- name: freq_GSM_DL
  id: variable
  parameters:
    value: 950e6
  states: {}
- name: freq_GSM_UL
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: freq_WBFM
  id: variable
  parameters:
    value: 98e6
  states: {}
- name: freq_iridium
  id: variable
  parameters:
    value: 1.61885e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: freq
    gain: '32'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 2.4e9
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [soapy_hackrf_source_0, '0', fosphor_qt_sink_c_0, '0']
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']

metadata:
  file_format: 1
